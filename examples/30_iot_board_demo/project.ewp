# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: packages\tinycrypt-v1.0.0\include; ..\..\drivers; packages\FlexibleButton; ..\..\rt-thread\components\libc\compilers\common; ..\..\libraries\CMSIS\Device\ST\STM32L4xx\Include; ..\..\rt-thread\components\net\sal_socket\include; packages\icm20608-v1.0.0; modules\player; ..\..\rt-thread\components\drivers\audio; ..\..\rt-thread\components\net\sal_socket\include\dfs_net; ..\..\rt-thread\components\net\lwip-2.0.2\src; ..\..\rt-thread\components\libc\compilers\dlib; ..\..\libraries\STM32L4xx_HAL_Driver\inc; ..\..\rt-thread\components\dfs\filesystems\elmfat; ..\..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select; ..\..\rt-thread\components\net\lwip-2.0.2\src\include; modules\event; ..\..\rt-thread\components\drivers\include; ports\easyflash; packages\pahomqtt-v1.0.0\MQTTPacket\src; ..\..\rt-thread\include; ports\cloudsdk; ..\..\rt-thread\components\drivers\sensors; ..\..\libraries\wifi; .; modules\iotb_workqeue; ports\fal; modules\infrared; packages\pahomqtt-v1.0.0\MQTTClient-RT; packages\qrcode-v0.1.0\inc; packages\netutils-v1.0.0\ntp; ..\..\libraries\cloudsdk\inc; ..\..\rt-thread\components\net\sal_socket\include\socket; ..\..\drivers\audio; modules\key; packages\aht10-v1.0.0; ..\..\rt-thread\components\drivers\spi\sfud\inc; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4; packages\fal-v0.2.0\inc; ..\..\rt-thread\components\dfs\include; ..\..\libraries\CMSIS\Include; ..\..\rt-thread\components\net\sal_socket\impl; applications; packages\cJSON-v1.0.2; packages\webclient-v2.0.1\inc; packages\stm32_sdio-v1.0.2; ..\..\rt-thread\components\finsh; ..\..\rt-thread\components\drivers\spi; modules\lcd; ..\..\rt-thread\components\drivers\wlan; ..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket; ..\..\libraries\rt_ota\inc; packages\infrared-v0.1.0\inc; modules\sensors; ..\..\rt-thread\libcpu\arm\cortex-m4; ..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include; ..\..\rt-thread\components\utilities\ymodem; ..\..\rt-thread\components\net\netdev\include; packages\ap3216c-v1.0.0; ..\..\rt-thread\libcpu\arm\common; modules\ymodem; ..\..\libraries\smartconfig\inc; ..\..\rt-thread\components\dfs\filesystems\devfs; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif; packages\EasyFlash-v3.2.1\inc; ports\wifi
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rt-thread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\drivers\linker_scripts\stm32l475ve_app.icf
  ILINK.IlinkAdditionalLibs: ..\..\libraries\cloudsdk\libs\libcloudsdk_2.0.0_armcm4_iar.a; ..\..\libraries\wifi\libwifi_6181_0.2.5_armcm4_iar.a; ..\..\libraries\rt_ota\libs\librt_ota_noalgo_0.1.2_stm32l4_iar.a; ..\..\libraries\smartconfig\libs\libsmartconfig_1.0.0_armcm4_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptStrategy: 0
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group iotb_event
    modules/event/: iotb_event.c
  group iotb_infrared
    modules/infrared/: app_infrared.c
  group iotb_job
    modules/iotb_workqeue/: iotb_workqeue.c
  group iotb_key
    modules/key/: iotb_key_process.c
  group iotb_lcd
    modules/lcd/: iotb_lcd_process.c
  group iotb_player
    modules/player/: wav_play.c
  group iotb_sensor
    modules/sensors/: iotb_sensor.c
  group iotb_ymodem
    modules/ymodem/: ymodem_update.c
  group aht10
    packages/aht10-v1.0.0/: aht10.c
  group ap3216c
    packages/ap3216c-v1.0.0/: ap3216c.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group EasyFlash
    packages/EasyFlash-v3.2.1/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.2.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_sfud_port.c fal_flash_stm32l4_port.c
  group flex_button
    packages/FlexibleButton/: flexible_button.c
  group icm20608
    packages/icm20608-v1.0.0/: icm20608.c
  group Infrared_frame
    packages/infrared-v0.1.0/src/: infrared.c drv_infrared.c nec_decoder.c
  group NetUtils
    packages/netutils-v1.0.0/ntp/: ntp.c
  group paho-mqtt
    packages/pahomqtt-v1.0.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.0.0/MQTTClient-RT/: paho_mqtt_pipe.c
  group qrcode
    packages/qrcode-v0.1.0/src/: qrcode.c
  group stm32_sdio
    packages/stm32_sdio-v1.0.2/: stm32_sdio.c
  group TinyCrypt
    packages/tinycrypt-v1.0.0/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
  group WebClient
    packages/webclient-v2.0.1/src/: webclient.c webclient_file.c
  group cloudsdk
    ports/cloudsdk/: rt_cld_port.c
  group wifi
    ports/wifi/: wifi_config.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/audio/: audio.c audio_pipe.c
    ../../rt-thread/components/drivers/hwtimer/: hwtimer.c
    ../../rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../rt-thread/components/drivers/pm/: pm.c
    ../../rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    ../../rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_msd.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Sensors
    ../../rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    ../../rt-thread/components/utilities/ymodem/: ymodem.c
  group STM32L4xx_HAL_Driver
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l475xx.s
    ../../libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_sai.c
  group Drivers
    ../../drivers/: board.c drv_clock.c drv_gpio.c drv_qspi_flash.c drv_spi_tfcard.c drv_lcd.c drv_usart.c drv_i2c.c drv_spi.c drv_sdio_adapter.c drv_qspi.c drv_wlan.c drv_pm.c drv_pmtimer.c drv_wakeup.c drv_pwm.c drv_hwtimer.c
    ../../drivers/audio/: drv_es8388.c drv_sound.c
