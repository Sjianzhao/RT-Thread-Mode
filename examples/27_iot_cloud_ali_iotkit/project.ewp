# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MQTT_COMM_ENABLED; MQTT_DIRECT; IOTX_WITHOUT_TLS; IOTX_NET_INIT_WITH_PK_EXT; _PLATFORM_IS_RTTHREAD_; IOTX_WITHOUT_ITLS; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\rt-thread\components\libc\compilers\common; ports\fal; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\utils\misc; ..\..\rt-thread\components\net\sal_socket\include\dfs_net; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\packages\LITE-utils; ..\..\rt-thread\components\libc\compilers\dlib; ..\..\libraries\STM32L4xx_HAL_Driver\inc; ..\..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select; ..\..\rt-thread\components\drivers\include; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\mqtt\Link-MQTT\MQTTPacket; ports\easyflash; ..\..\rt-thread\components\net\lwip-2.0.2\src; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\log\LITE-log; ..\..\rt-thread\include; ..\..\libraries\CMSIS\Device\ST\STM32L4xx\Include; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\utils\digest; ..\..\libraries\wifi; .; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\mqtt\Link-MQTT; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\sdk-impl\imports; ..\..\rt-thread\components\net\sal_socket\include\socket; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\sdk-impl\exports; ..\..\rt-thread\components\net\sal_socket\include; ..\..\rt-thread\components\net\lwip-2.0.2\src\include; ..\..\rt-thread\components\drivers\spi\sfud\inc; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4; packages\fal-v0.2.0\inc; ..\..\rt-thread\components\dfs\include; ..\..\libraries\CMSIS\Include; ..\..\rt-thread\components\net\sal_socket\impl; applications; packages\stm32_sdio-v1.0.2; ..\..\rt-thread\components\finsh; ..\..\rt-thread\components\drivers\spi; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\packages\iot-coap-c; ..\..\rt-thread\components\drivers\wlan; ..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket; ..\..\libraries\rt_ota\inc; ..\..\rt-thread\libcpu\arm\cortex-m4; ..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include; ..\..\rt-thread\components\net\netdev\include; ..\..\rt-thread\components\dfs\filesystems\devfs; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\sdk-impl; ..\..\rt-thread\libcpu\arm\common; packages\ali-iotkit-v2.0.3\iotkit-embedded\src\system\iotkit-system; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif; packages\EasyFlash-v3.2.1\inc; ports\wifi
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rt-thread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\drivers\linker_scripts\stm32l475ve.icf
  ILINK.IlinkAdditionalLibs: ..\..\libraries\wifi\libwifi_6181_0.2.5_armcm4_iar.a; ..\..\libraries\rt_ota\libs\librt_ota_noalgo_0.1.2_stm32l4_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group ali-iotkit
    packages/ali-iotkit-v2.0.3/samples/mqtt/: mqtt-example.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/coap/: iotx_ca_cert.c iotx_coap_api.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/packages/iot-coap-c/: CoAPDeserialize.c CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPSerialize.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/log/LITE-log/: lite-log.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/mqtt/Link-MQTT/: mqtt_client.c mqtt_instance.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/mqtt/Link-MQTT/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/packages/LITE-utils/: json_parser.c json_token.c lite-utils_testsuites.c mem_stats.c string_utils.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/system/iotkit-system/src/: ca.c class_interface.c guider.c id2_guider.c iotx_device.c report.c sdk-impl.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/utils/misc/: utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
    packages/ali-iotkit-v2.0.3/iotkit-embedded/src/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c utils_sha256.c
    packages/ali-iotkit-v2.0.3/ports/rtthread/: HAL_OS_rtthread.c HAL_TCP_rtthread.c HAL_UDP_rtthread.c
  group EasyFlash
    packages/EasyFlash-v3.2.1/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.2.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_sfud_port.c fal_flash_stm32l4_port.c
  group stm32_sdio
    packages/stm32_sdio-v1.0.2/: stm32_sdio.c
  group wifi
    ports/wifi/: wifi_config.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32L4xx_HAL_Driver
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l475xx.s
    ../../libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers
    ../../drivers/: board.c drv_clock.c drv_gpio.c drv_qspi_flash.c drv_usart.c drv_sdio_adapter.c drv_qspi.c drv_wlan.c
