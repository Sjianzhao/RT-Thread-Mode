# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SET_TRUSTED_CERT_IN_SAMPLES; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\rt-thread\components\libc\compilers\common; ..\..\rt-thread\components\net\sal_socket\include; ports\fal; ..\..\rt-thread\components\dfs\filesystems\devfs; ..\..\rt-thread\components\finsh; ..\..\rt-thread\components\net\sal_socket\include\dfs_net; ..\..\rt-thread\components\libc\compilers\dlib; ..\..\libraries\STM32L4xx_HAL_Driver\inc; packages\azure-iot-sdk-v1.2.9\azure\deps\parson; ..\..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select; ..\..\rt-thread\components\drivers\include; ports\easyflash; packages\azure-iot-sdk-v1.2.9\azure\c-utility\pal\inc; ..\..\rt-thread\include; packages\azure-iot-sdk-v1.2.9\azure\c-utility\inc; packages\azure-iot-sdk-v1.2.9\azure\c-utility\pal\lwip; ..\..\libraries\wifi; packages\azure-iot-sdk-v1.2.9\azure\iothub_client\inc; .; ..\..\libraries\CMSIS\Device\ST\STM32L4xx\Include; packages\azure-iot-sdk-v1.2.9\azure\iothub_client\src; packages\azure-iot-sdk-v1.2.9\azure\c-utility\src; packages\netutils-v1.0.0\ntp; packages\azure-iot-sdk-v1.2.9\azure\c-utility\inc\azure_c_shared_utility; packages\mbedtls-v2.6.0\mbedtls\include; ..\..\rt-thread\components\net\lwip-2.0.2\src; packages\azure-iot-sdk-v1.2.9\azure\umqtt\src; ..\..\rt-thread\components\net\lwip-2.0.2\src\include; ..\..\rt-thread\components\drivers\spi\sfud\inc; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4; packages\mbedtls-v2.6.0\ports\inc; packages\fal-v0.2.0\inc; ..\..\rt-thread\components\dfs\include; ..\..\libraries\CMSIS\Include; packages\azure-iot-sdk-v1.2.9\azure\c-utility\pal; applications; packages\azure-iot-sdk-v1.2.9\azure\serializer\inc; packages\stm32_sdio-v1.0.2; ports\wifi; ..\..\rt-thread\components\drivers\spi; ..\..\rt-thread\components\drivers\wlan; packages\azure-iot-sdk-v1.2.9\azure\c-utility\adapters; packages\azure-iot-sdk-v1.2.9\azure-port\pal\inc; ..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket; ..\..\libraries\rt_ota\inc; ..\..\rt-thread\components\net\sal_socket\impl; packages\mbedtls-v2.6.0\mbedtls\include\mbedtls; ..\..\rt-thread\libcpu\arm\cortex-m4; ..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include; packages\azure-iot-sdk-v1.2.9\azure\serializer\src; ..\..\rt-thread\components\net\netdev\include; packages\azure-iot-sdk-v1.2.9\azure\umqtt\inc; packages\azure-iot-sdk-v1.2.9\azure\umqtt\inc\azure_umqtt_c; ..\..\rt-thread\libcpu\arm\common; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif; packages\EasyFlash-v3.2.1\inc; packages\azure-iot-sdk-v1.2.9\azure; ..\..\rt-thread\components\net\sal_socket\include\socket; packages\azure-iot-sdk-v1.2.9\azure\c-utility\pal\generic
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rt-thread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\drivers\linker_scripts\stm32l475ve.icf
  ILINK.IlinkAdditionalLibs: ..\..\libraries\wifi\libwifi_6181_0.2.5_armcm4_iar.a; ..\..\libraries\rt_ota\libs\librt_ota_noalgo_0.1.2_stm32l4_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group azure
    packages/azure-iot-sdk-v1.2.9/azure/c-utility/src/: xlogging.c singlylinkedlist.c buffer.c consolelogger.c constbuffer.c constmap.c doublylinkedlist.c gballoc.c gb_stdio.c gb_time.c hmac.c hmacsha256.c httpapiex.c httpapiexsas.c httpheaders.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c string_tokenizer.c urlencode.c usha.c vector.c xio.c strings.c
    packages/azure-iot-sdk-v1.2.9/azure-port/lib/: c_utility_crt_abstractions.c c_utility_sha1.c c_utility_base64.c azure_certs.c
    packages/azure-iot-sdk-v1.2.9/azure/iothub_client/src/: iothub_client_ll.c iothub_device_client_ll.c iothub_client_core_ll.c iothub_client_authorization.c iothub_message.c iothub_client_diagnostic.c iothub_client_ll_uploadtoblob.c blob.c iothub.c iothubtransportmqtt.c iothubtransport_mqtt_common.c iothub_client_retry_control.c iothubtransporthttp.c
    packages/azure-iot-sdk-v1.2.9/azure/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
    packages/azure-iot-sdk-v1.2.9/azure/deps/parson/: parson.c
    packages/azure-iot-sdk-v1.2.9/azure/serializer/src/: codefirst.c agenttypesystem.c commanddecoder.c datamarshaller.c datapublisher.c dataserializer.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c schemaserializer.c
    packages/azure-iot-sdk-v1.2.9/azure-port/rt-thread/: lock.c threadapi.c tickcounter.c
    packages/azure-iot-sdk-v1.2.9/azure/c-utility/pal/: socket_async.c dns_async.c
    packages/azure-iot-sdk-v1.2.9/azure-port/pal/src/: agenttime.c azure_platform.c tlsio_mbedtls.c socketio_berkeley.c
    packages/azure-iot-sdk-v1.2.9/azure/c-utility/adapters/: httpapi_compact.c
    packages/azure-iot-sdk-v1.2.9/samples/: iothub_ll_telemetry_sample.c iothub_ll_c2d_sample.c
  group EasyFlash
    packages/EasyFlash-v3.2.1/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.2.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_sfud_port.c fal_flash_stm32l4_port.c
  group mbedtls
    packages/mbedtls-v2.6.0/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    packages/mbedtls-v2.6.0/ports/src/: timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group NetUtils
    packages/netutils-v1.0.0/ntp/: ntp.c
  group stm32_sdio
    packages/stm32_sdio-v1.0.2/: stm32_sdio.c
  group wifi
    ports/wifi/: wifi_config.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    ../../rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c proto_mbedtls.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32L4xx_HAL_Driver
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l475xx.s
    ../../libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers
    ../../drivers/: board.c drv_clock.c drv_gpio.c drv_qspi_flash.c drv_usart.c drv_sdio_adapter.c drv_qspi.c drv_wlan.c
