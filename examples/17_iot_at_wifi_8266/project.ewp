# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\rt-thread\components\net\sal_socket\impl; ..\..\rt-thread\components\net\sal_socket\include; ..\..\rt-thread\include; ..\..\libraries\CMSIS\Device\ST\STM32L4xx\Include; ..\..\rt-thread\libcpu\arm\cortex-m4; ..\..\libraries\CMSIS\Include; ..\..\rt-thread\components\net\netdev\include; ..\..\rt-thread\components\net\at\at_socket; .; ..\..\rt-thread\libcpu\arm\common; applications; ..\..\libraries\STM32L4xx_HAL_Driver\inc; packages\at_device-v1.6.0; ..\..\rt-thread\components\finsh; ..\..\rt-thread\components\libc\compilers\dlib; ..\..\rt-thread\components\libc\compilers\common; ..\..\rt-thread\components\drivers\include; ..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket; ..\..\rt-thread\components\net\at\include; ..\..\drivers; ..\..\rt-thread\components\net\sal_socket\include\socket
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rt-thread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\drivers\linker_scripts\stm32l475ve.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group at_device
    packages/at_device-v1.6.0/: at_socket_esp8266.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group AT
    ../../rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../rt-thread/components/net/at/at_socket/: at_socket.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_at.c
  group STM32L4xx_HAL_Driver
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l475xx.s
    ../../libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers
    ../../drivers/: board.c drv_clock.c drv_gpio.c drv_usart.c
