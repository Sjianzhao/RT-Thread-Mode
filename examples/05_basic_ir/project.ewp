# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\drivers; ..\..\rt-thread\include; ..\..\libraries\CMSIS\Device\ST\STM32L4xx\Include; ..\..\rt-thread\libcpu\arm\cortex-m4; .; ..\..\rt-thread\libcpu\arm\common; applications; ..\..\libraries\STM32L4xx_HAL_Driver\inc; ..\..\rt-thread\components\finsh; packages\infrared-v0.1.1\inc; ..\..\rt-thread\components\drivers\include; ..\..\libraries\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rt-thread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\drivers\linker_scripts\stm32l475ve.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Infrared_frame
    packages/infrared-v0.1.1/src/: infrared.c nec_decoder.c drv_infrared.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../rt-thread/components/drivers/hwtimer/: hwtimer.c
    ../../rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group STM32L4xx_HAL_Driver
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l475xx.s
    ../../libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers
    ../../drivers/: board.c drv_clock.c drv_gpio.c drv_usart.c drv_pwm.c drv_hwtimer.c
